Commit message: update lidar imu files

File: scripts/my_robot.urdf (robot description, URDF)
Before this commit: robot my_robot_2d, 2 links, 1 joints
Joints:
- joint imu_link_joint: origin xyz=0 0 0 rpy=0 3.14 1.57 -> xyz=0 0 0 rpy=0 0 3.14
